# Repository mocona05/Lattepanda-Measurement-Shield

File README.md:

# Lattepanda-Measurement-Shield

Lattepanda Measurement Shield

https://tk-labs.blogspot.kr/2017/04/lattepanda-single-board-pc-mersument.html

https://youtu.be/Gao8uBBO_YQ?list=UUIPe5kHdhJTlKDBbaLlJSWA

https://tk-labs.blogspot.kr/2017/07/lattepanda-shield-4-wire-kelvin-circuit.html

https://youtu.be/S4dbSf8vbH0?list=UUIPe5kHdhJTlKDBbaLlJSWA

https://youtu.be/iEvZpjPi1Qs?list=UUIPe5kHdhJTlKDBbaLlJSWA

https://youtu.be/Fq8yy6oz41c?list=UUIPe5kHdhJTlKDBbaLlJSWA

https://tk-labs.blogspot.kr/2017/07/lattepanda-shiled-thermocouple-k-type.html

https://youtu.be/_V4gtJXVWEc

## EAGLE design Lattepanda_Shild/Lattepanda_shild_v1.4.brd

Parts:
BAT1: MS621
C1, C2, C7, C8, C9, C10, C11, C13, C14, C17, C30, C31, C34, C42, C48, C51: 0.1uF; C0603
C3: 1000pF/1%; C050-025X075
C4: 1000pF; C050-025X075
C5, C6: 10uF/16V; C3216
C12, C25, C32, C38, C40, C52, C57, C62, C64, C67: 1uF; C0603
C15: 1uF/10V; C0603
C16: 10uF/35V; C3225
C18: 2.2nF/50V; C0603
C19, C45: 0.1uF/50V; C0603
C20: 470pF; C0603
C21, C36: 4.7uF; C2012
C22, C24: 0.22uF; C0603
C23: 10nF/50V; C0603
C26: 0.1uF/50V; C1608-
C27, C29: 1nF; C0603
C28, C35, C41, C54, C55, C63, C65: 10nF; C0603
C33, C66: 22uF/10V; C3216-18/T
C37: 10nF; C1608-
C39: 470uF; D/7343-31W
C43, C44, C46, C47: 47pF; C0603
C49, C50: 12.5pF; C0603
C53: 1uF/16V; C0603
C56: 2.2uF/35V; C2012
C58, C59: 18pF; C0603
C60, C61: 100nF; C0603
D1, D5, D6, D9, D10: BAV99; SOT23
D2, D3, D7: NUP2105; SOT23
D4: MBRS540T3; SMC
D8: BAT54C; SOT23
F1: 1812L110/33; 1812L
F2: FSMD300R; 1812L
IC1: LT1634ACS-1.25; MS8
IC2: LT6202; SOT23-5L
IC3: LM311; SO8
IC4: MAX3232CPW; PW_R-PDSO-G16
IC5: CXDM4060P; SOT89
IC6: MIC5219-3.3V; SOT23-5
IC7: AOZ1284PI; S08-EP1
IC8: AD8495; MSOP8
IC9: TLE4266; SOT223-4
IC10: PAM8403; SOIC16N
IC11: TLE4266GSV10; SOT223-4
IC12: SN65HVD230; SO8
IC13: STM32F373X; TQFP48
IC14, IC15: LT1783; SOT23-5
IC16: LT1634ACS-2.5; MS8
J1: DC_POWER; SPC4077
J2: PJ-327; PJ-327-2
J3: B0; SJ
J4: USB A/F; USB_AF_SIDE
JP1: LC; ED350V-02P
JP2: RELAY1; ED350V-03P
JP3: Latte_5V; 2X02
JP4: FAN; MA02-1-MOL
JP5: Latte_Intel; 2X05M
JP6: LOW_SIDE_OUT; ED350V-02P
JP7, JP8: 4WIR1; ED350V-02P
JP9: DC-IN; ED350V-02P
JP10: RS232C_LA; ED350V-02P
JP11: DI; MOLEX5267-04
JP12: RS232C_MCU; ED350V-03P
JP13: TC1; ED350V-02P
JP14: ADC1/COP1; ED350V-02P
JP15: L-SPEAKER; ED350V-02P
JP16: R-SPEAKER; ED350V-02P
JP17: ADC2/COP2; ED350V-02P
JP18: CAN-BUS; ED350V-02P
JP19: i2C; MOLEX5267-04
JP20: SWD; 1X04M
JP21: BOOT; 1X02M
JP22, JP23: DAC1; ED350V-02P
L1, L2: 100uH/1812R-104F; L1210
L3, L4: BEAD; L0603
L5: 22uH; SHP1260P-F
L6: ACT45B-510-2P-TL003; ACT45B
L7: SRF0602-100Y; SRF0602
L8: SRF0905-100Y; SRF0905
L9: 10uH; L0805
Q1: Si2333DS; SOT23
Q2, Q4, Q5: BSS138SOT23; SOT23
Q3, Q8, Q10: AGN2004; ANG200X
Q6: 2N7002; SOT23
Q7, Q9, Q11, Q13, Q18: DTDG23YP; MPT3
Q12: 2SB1694; SOT323
Q14, Q15, Q16, Q19: DTC114EUA; SC59-BEC
Q17: AGN2003; ANG200X
Q20: 32.768k; MC-306
Q21: 8MHz; SMD5032
R1, R2, R15, R32, R35: 1k; R0603
R3: 1kF; R0603
R4, R24, R25, R47, R48, R51, R54: 10k; R0603
R5, R58: 18k; R0603
R6, R7, R8, R9, R23, R26, R31, R38, R40, R41, R44: 10kF; R0603
R10, R20: 100kF; R0603
R11, R12, R13: 100k; R0603
R14, R21: 47k; R0603
R16: 360; R0603
R17: 3.6k; R0603
R18, R19: 499; R0603
R22, R55: 11k; R0603
R27: 1M; R0603
R28, R29: 27; R0603
R30: 46.6k; R0603
R33: 1.5k; R0603
R34: 0; R0603
R36, R52, R53: 30kF; R0603
R37: 52.3kF; R0603
R39, R43: 115kF; R0603
R42: 120; R0603@1
R45, R46: 2.2k; R0603
R49, R50: 53kF; R0603
R56, R57: 100; R0603
S1: CAN_TERMI; 255SB
SW1: RESET\; DTSM-3
VR1: 50; R-TRIMMER-3313J
VR2: 500; R-TRIMMER-3313J
VR3, VR4: 10k; R-TRIMMER-3313J
ZD1: SM6T39CAY; SMB
ZD2: RD10S; DSMM

Connections:
+1.25V_REF: C1.2, IC1.6 (VOUT), IC2.3 (+IN), IC8.2 (REF), R5.2
+3V3: C10.1, C17.2, C21.1, C48.2, C51.1, C52.1, C67.2, D1.S (C), D5.S (C), D6.S (C), D8.G (1), IC4.16 (VCC), IC6.5 (OUT), IC12.3 (VCC), IC13.17 (VDD_2), IC13.48 (VDD_1), JP19.1, JP20.1, JP21.1, L9.1, Q17.1, R6.2, R7.2, R45.1, R46.1, R47.2, R48.2, R51.2
+5V: C33.+, C34.1, J3.2, JP3.1, JP3.3, JP4.1, L5.1, L8.1, Q19.3 (OUT), R37.2
+5V/1: C2.1, C7.1, C36.1, C37.2, IC2.5 (V+), IC3.8 (V+), IC9.3 (Q), Q17.3, Q17.6, R2.2, R5.1, R10.2, R11.2, R15.2, R58.1
+5V/3: C15.2, C32.1, C39.+, C40.2, C42.2, C66.+, IC6.1 (IN), IC6.3 (EN), IC10.4 (PVDD), IC10.5 (!MUTE), IC10.6 (VDD), IC10.12 (!SHDN), IC10.13 (PVDD), JP6.1, L8.2, Q3.1, Q8.1, Q10.1
+10V: C31.1, C53.2, C60.2, C61.2, D9.S (C), D10.S (C), IC8.7 (V+), IC11.3 (Q), IC14.5 (V+), IC15.5 (V+)
+UB: C30.1, F2.P$2 (2), J3.1, R24.2
AGND: C1.1, C2.2, C4.2, C6.2, C7.2, C13.1, C14.2, C27.2, C29.2, C31.2, C35.2, C36.2, C37.1, C38.2, C41.2, C53.1, C54.1, C55.1, C56.2, C57.1, C60.1, C61.1, C62.2, C63.1, C64.1, C65.1, D1.G (A), D2.D (PIN3), D5.G (A), D6.G (A), D9.G (A), D10.G (A), IC1.4 (GND), IC2.2 (V-), IC3.1 (G), IC3.4 (V-), IC8.3 (V-), IC13.8 (VSSA/VREF-), IC13.23 (VREFSD-), IC14.2 (V-), IC15.2 (V-), IC16.4 (GND), JP1.2, JP7.2, JP14.2, JP17.2, JP22.2, JP23.2, L1.2, L7.2, Q2.S, Q6.S, Q10.7 (O), R12.1, R27.1, R40.1, R41.1, R44.1, R49.1, R50.1
BOOT1: IC13.44 (BOOT0), JP21.2, R54.2
CANH: C43.1, D7.G (PIN1), JP18.1, L6.4, R42.1
CANL: C47.2, D7.S (PIN2), JP18.2, L6.3, S1.3 (S)
CAN_RX: IC12.4 (RXD), IC13.45 (PB8)
CAN_TX: IC12.1 (TXD), IC13.46 (PB9)
COMP1_P: C35.1, D5.D (AC), IC13.11 (PA1), R39.2, R40.2
COMP2_P: C41.1, D6.D (AC), IC13.13 (PA3), R43.2, R44.2
C_ADC: D1.D (AC), IC13.28 (PD8), R4.2
C_CTL: IC13.15 (PA5), R1.1
D+: J4.3 (D+), R29.2, R33.1
D-: J4.2 (D-), R28.2
DAC1_OUT1: C54.2, IC13.14 (PA4), IC14.3 (+IN)
DAC2_OUT1: C55.2, IC13.16 (PA6), IC15.3 (+IN)
DC-IN: F1.P$1 (1), IC5.2 (D), IC5.2@1 (D), ZD1.A
DI_CH1: IC13.19 (PB1), Q14.3 (OUT)
DI_CH2: IC13.20 (PB2), Q15.3 (OUT)
DI_CH3: IC13.21 (PE8), Q16.3 (OUT)
GND: BAT1.-, C8.1, C15.1, C17.1, C20.1, C21.2, C26.1, C32.2, C39.-, C40.1, C42.1, C43.2, C44.2, C45.2, C46.2, C47.1, C48.1, C49.1, C50.1, C51.2, C52.2, C58.1, C59.1, C66.-, C67.1, D7.D (PIN3), IC4.15 (GND), IC6.2 (GND), IC9.4 (GND), IC10.2 (PGND), IC10.9 (NC), IC10.11 (GND), IC10.15 (PGND), IC11.4 (GND), IC12.2 (GND), IC12.8 (RS), IC13.47 (VSS_1), JP11.1, JP19.2, JP20.3, L3.2, L4.2, L8.3, Q7.EMITTER (GND), Q9.EMITTER (GND), Q11.EMITTER (GND), Q13.EMITTER (GND), Q14.1 (GND), Q15.1 (GND), Q16.1 (GND), Q18.EMITTER (GND), R54.1, SW1.2
GNDINT: C16.2, C19.2, C30.2, C33.-, C34.2, D3.D (PIN3), D4.A, IC7.3 (GND), J1.1, J4.4 (GND), JP3.2, JP3.4, JP4.2, JP9.2, L7.1, L8.4, R20.2, R22.1, R23.1, R25.1, R30.2, R38.1, ZD1.C (K)
KELVIN_M: C12.1, C13.2, D2.S (PIN2), IC13.27 (PB15), R18.2
KELVIN_P: C12.2, C14.1, D2.G (PIN1), IC13.26 (PB14), R19.2
L1: IC13.42 (PB6), Q7.BASE (IN)
L2: IC13.38 (PA15), Q11.BASE (IN)
L3: IC13.36 (PF7), Q6.G
LC_PULSE: IC3.7 (OUT), IC13.35 (PF6), R13.2, R14.2, R15.1
LEFT: C24.2, J2.2
unnamed: JP6.2, Q13.COLLECTOR (OUT)
unnamed: JP12.3, L4.1
unnamed: IC7.6 (FB), R37.1, R38.2
unnamed: C23.2, IC7.2 (BST)
unnamed: C46.1, IC12.6 (CANL), L6.2
unnamed: C44.1, IC12.7 (CANH), L6.1
unnamed: R17.1, VR2.2
unnamed: C23.1, R34.1
unnamed: D4.C, IC7.1 (LX), L5.2, R34.2
unnamed: C18.1, IC7.5 (COMP)
unnamed: C18.2, R23.2
unnamed: R42.2, S1.2
unnamed: R50.2, VR4.2
unnamed: C11.1, IC4.5 (C2-)
unnamed: C11.2, IC4.4 (C2+)
unnamed: C10.2, IC4.2 (V+)
unnamed: IC15.4 (-IN), R53.1, VR4.1
unnamed: D10.D (AC), IC15.1 (OUT), R53.2, R57.1
unnamed: IC7.8 (EN), R21.1, R22.2
unnamed: JP7.1, R18.1
unnamed: IC7.4 (FSW), R30.1
unnamed: JP8.2, R19.1
unnamed: C19.1, IC7.7 (SS)
unnamed: D8.D (3), IC13.1 (VBAT), R55.1
unnamed: C8.2, IC4.6 (V-)
unnamed: C9.2, IC4.1 (C+)
unnamed: IC4.8 (RIN2), JP10.2
unnamed: C9.1, IC4.3 (C1-)
unnamed: IC2.1 (OUT), Q12.2 (B), R10.1
unnamed: Q8.8 (2), Q9.COLLECTOR (OUT)
unnamed: IC4.7 (DOUT2), JP10.1
unnamed: JP5.9, L3.1
unnamed: IC13.7 (NRST), R51.1, SW1.1
unnamed: C59.2, IC13.6 (PF1/OSC=>), Q21.3 (2)
unnamed: IC4.13 (RIN1), JP12.2
unnamed: IC3.5 (BA), IC3.6 (BS)
unnamed: C57.2, C64.2, C65.2, IC13.9 (VDDA/VREF+), IC13.24 (VDDSD), L9.2
unnamed: C6.1, IC3.3 (-IN), R14.1
unnamed: IC4.14 (DOUT1), JP12.1
unnamed: C28.2, C29.1, IC8.1 (-IN), R31.2
unnamed: C27.1, C28.1, IC8.8 (+IN), R26.2
unnamed: IC10.7 (INL), R35.2
unnamed: IC10.1 (+OUT_L), JP15.1
unnamed: JP13.2, R27.2, R31.1
unnamed: JP13.1, R26.1
unnamed: IC8.5 (SENS), IC8.6 (OUT), R36.1
unnamed: C5.1, IC3.2 (+IN), R11.1, R12.2, R13.1
unnamed: JP8.1, Q12.3 (C)
unnamed: JP14.1, R39.1
unnamed: JP17.1, R43.1
unnamed: IC10.3 (-OUT_L), JP15.2
unnamed: IC10.14 (-OUT_R), JP16.1
unnamed: IC10.16 (+OUT_R), JP16.2
unnamed: IC10.10 (INR), R32.2
unnamed: C25.1, IC10.8 (VREF)
unnamed: C25.2, J2.1
unnamed: C24.1, R35.1
unnamed: F2.P$1 (1), J4.1 (VBUS)
unnamed: JP22.1, R56.2
unnamed: Q1.S (SOURCE), R2.1
unnamed: C20.2, IC6.4 (BP)
unnamed: Q2.D, R3.1
unnamed: R16.1, VR1.2
unnamed: C22.1, R32.1
unnamed: Q17.8 (2), Q18.COLLECTOR (OUT)
unnamed: Q17.4 (S), Q17.5 (S), R16.2
unnamed: C62.1, C63.2, IC13.25 (VREFSD+), IC16.6 (VOUT), R58.2
unnamed: L1.1, Q3.5 (S)
unnamed: IC2.4 (-IN), Q12.1 (E), VR1.1, VR2.1
unnamed: IC14.4 (-IN), R52.1, VR3.1
unnamed: Q17.2 (O), Q17.7 (O), R17.2
unnamed: Q10.4 (S), Q10.5 (S)
unnamed: C3.1, C4.1, C5.2, L2.2, Q10.2 (O)
unnamed: Q1.G (GATE), Q2.G, R1.2
unnamed: Q10.8 (2), Q11.COLLECTOR (OUT)
unnamed: Q3.2 (O), Q3.6, Q10.3
unnamed: C3.2, Q6.D
unnamed: L2.1, Q10.6
unnamed: Q3.8 (2), Q7.COLLECTOR (OUT)
unnamed: Q19.1 (GND), R33.2
unnamed: Q1.D (DRAIN), Q3.4 (S), R3.2, R4.1
unnamed: JP1.1, Q3.3
unnamed: D9.D (AC), IC14.1 (OUT), R52.2, R56.1
unnamed: R49.2, VR3.2
unnamed: JP2.2, Q8.3, Q8.6
unnamed: C58.2, IC13.5 (PF0/OSC<=), Q21.1
unnamed: JP2.1, Q8.2 (O), Q8.7 (O)
unnamed: JP2.3, Q8.4 (S), Q8.5 (S)
unnamed: JP23.1, R57.2
unnamed: IC13.31 (PA10), JP19.3, R45.2
unnamed: BAT1.+, D8.S (2), R55.2
unnamed: JP11.2, Q16.2 (IN)
unnamed: JP11.3, Q15.2 (IN)
unnamed: C49.2, IC13.3 (PC14), Q20.1
unnamed: C50.2, IC13.4 (PC15), Q20.4 (2)
unnamed: JP11.4, Q14.2 (IN)
unnamed: IC5.3 (G), R20.1, ZD2.A
unnamed: F1.P$2 (2), J1.3, JP9.1
PWM1: IC13.41 (PB5), Q13.BASE (IN)
RANGE: IC13.29 (PA8), Q18.BASE (IN)
RELAY1: IC13.43 (PB7), Q9.BASE (IN)
RIGHT: C22.2, J2.3
RXD_LA: IC4.9 (ROUT2), Q4.D, R6.1
RXI2: IC4.12 (ROUT1), IC13.40 (PB4)
SCL: IC13.30 (PA9), JP19.4, R46.2
SWCLK: IC13.37 (PA14), JP20.4, R47.1
SWDIO: IC13.34 (PA13), JP20.2, R48.1
TC1_ADC: C38.1, IC13.18 (PB0), R36.2, R41.2
TXD_LA: IC4.10 (DIN2), Q5.D, R7.1
TXO2: IC4.11 (DIN1), IC13.39 (PB3)
UART_RXI: JP5.5, Q4.S, R8.1
UART_TXO: JP5.7, Q5.S, R9.1
USB_DM: D3.S (PIN2), IC13.32 (PA11), R28.1
USB_DP: D3.G (PIN1), IC13.33 (PA12), R29.1
USB_EN: IC13.2 (PC13), Q19.2 (IN), R24.1, R25.2
VDD: JP5.10, Q4.G, Q5.G, R8.2, R9.2
VEE: C16.1, IC5.1 (S), IC7.EX_PAD (VIN), L7.4, R21.2, ZD2.C
VPP: C26.2, C45.1, C56.1, IC9.1 (I), IC9.2 (INH), IC11.1 (I), IC11.2 (INH), L7.3

Notes on the sheet:
+5 Voltage Step Down Regulator
3W STEREO AUDIO AMP
Lattepanda Pin Header
USB
CAN BUS Driver
4-WIRE KELVIN
K-Type Range = -180°C to 1200°C
1.V REF = -200°C to
0.9V REF = -180°C to
0V REF = 0°C to
LC METER
DAC
THERMO COUPLE K-TYPE
RS232C
REGULATOR
DC10V REGULATOR
12BIT ADC
CH1
CH2
LOW SIDE OUT
RELAY OUT
DIGITAL IN
1.25V REF = -250°C to 1200°C
1. USB_EN회로 수정필요 PULL-DOWN 삭제, FET를 DIGITAL NPN TR로 변경
2. DIgital Input 회로 수정필요->큰문제없음
3. Kelvin 회로의 전류조정 가변저항이 회전방향이 반대임->변경완료
4. Kelvin 10mA TRIMMER 저항 용량 재검토, 멀티턴 저항으로 검토->공간적 제약이 문제로 포기
5. CM FILTER 인덕턴스 재검토-> 전원부 CM FILTER Pacage 교체

Board: 2 copper layers, 88.0 x 70.0 mm, 219 parts (0 on the bottom side), 152 nets.

## EAGLE design Lattepanda_Shild/Lattepanda_shild_v1.brd

Parts:
BAT1: MS621
C1, C3: 1000pF/1%; C050-025X075
C2, C5, C7, C8, C10, C11, C12, C16, C19, C26, C33, C35, C46, C49, C50, C53, C54, C55: 0.1uF; C0603
C4, C6: 10uF/16V; C3216
C9, C25, C27, C28, C39, C40, C41, C42, C44, C45, C48, C51, C52, C60, C61, C68, C70: 10nF; C0603
C13: 1uF/10V; C0603
C14: 10uF/35V; C3225
C15: 1uF/16V; C0805
C17: 2.2nF/50V; C0603
C18, C73: 0.1uF/50V; C0603
C20: 470pF; C0603
C21: 4.7uF; C2012
C22: 10nF/50V; C0603
C23: 1uF/50V; C2012
C24: 0.1uF/50V; C1608-
C29, C31: 22uF/10V; C3216
C30, C32: 0.22uF; C0603
C34, C37, C38, C47, C56, C59, C62, C67, C69, C71: 1uF; C0603
C36: 22uF/10V; C3528-21/T
C43: 470uF; D/7343-31W
C57, C58: 12.5pF; C0603
C63, C64: 100nF; C0603
C65, C66: 18pF; C0603
C72: 4.7uF/10V; C2012
D1, D4, D6, D7, D8: BAV99; SOT23
D2, D3: MBRS540T3; SMC
D5: NPU2105; SOT23
D9: BAT54C; SOT23
F1, F2: 1812L110/33; 1812L
IC1: ADR512; SOT23
IC2: LT6203; SOT23-5L
IC3: LM311; SO8
IC4: MAX3232CPW; PW_R-PDSO-G16
IC5: FAN3100; SOT23-5L_FAN3100
IC6: MIC5219-3.0V; SOT23-5
IC7: AOZ1284PI; S08-EP1
IC8, IC12: AD8495; MSOP8
IC9: TLE4266-2G; SOT223-4
IC10: PAM8403; SOIC16N
IC11: SN65HVD230; SO8
IC13: STM32F373X; TQFP48
IC14, IC15: LT1783; SOT23-5
IC16: ADR530; SOT23
IC17: LM2937IMP-10; SOT223
J1: DC_POWER; SPC4077
J2: PJ-327; PJ-327-2
JP1: LC; ED350V-02P
JP2: Latte_AVRISP; 2X03
JP3: Latte_5V; 2X02
JP4: Latte_Intel; 2X05M
JP5: Latte_Arduino; 2X12_SMD
JP6, JP7: 4WIR1; ED350V-02P
JP8, JP10, JP13: PWM_OUT; ED350V-02P
JP9: RS232C_LA; ED350V-02P
JP11: RS232C_STM; ED350V-02P
JP12: TC1; ED350V-02P
JP14: ADC1/COP1; ED350V-02P
JP15: TC2; ED350V-02P
JP16: CAN-BUS; ED350V-02P
JP17: ADC2/COP2; ED350V-02P
JP18: L-SPEAKER; ED350V-02P
JP19: R-SPEAKER; ED350V-02P
JP20: SWD; 1X04M
JP21: BOOT; 1X02M
JP22: DAC1; ED350V-02P
JP23: DAC2; ED350V-02P
L1: 220uH/1%; 0207/2V
L2: 100uH; 0207/2V
L3: 18uH; SHP1260P-F
L4, L5: BEAD; L0805
L6: ACT45B-510-2P-TL003; ACT45B
L7: BEAD; L0603
L8: 10uH; L0805
Q1, Q5, Q7, Q10, Q30, Q31: AGN2004; ANG200X
Q2, Q3: BSS138SOT23; SOT23
Q4, Q6, Q9, Q11, Q12, Q13: DTDG23YP; MPT3
Q8: 2SB1694; SOT323
Q14: Si2333DS; SOT23
Q15: 32.768k; MC-306
Q16: 8MHz; SMD5032
R1, R60: 330; R0603
R2, R3, R5, R6, R18, R23, R37, R41, R47: 10kF; R0603
R4, R59: 470kF; R0603
R7, R8, R11, R20: 47k; R0603
R9: 100kF; R0603
R10: 62k; R0603
R13, R34, R38: 1k; R0603
R15: 360; R0603
R16: 3.6k; R0603
R17, R40, R46: 115kF; R0603
R19: 300; R0603
R21, R56: 11k; R0603
R22, R29, R30, R54, R55, R61, R62: 10k; R0603
R24, R27, R43, R45, R57, R58: 100; R0603
R25, R44: 1M; R0603
R26, R35, R39, R48, R49: 100k; R0603
R28: 0; R0603
R31, R32: 27; R0603
R33: 1.5k; R0603
R36: 52.3kF; R0603
R42: 120; R0603@1
R50: 53kF; R0603
R51: 53k; R0603
R52, R53: 30kF; R0603
SW1: CSS-1210TB1; CSS-1210TB
VR1, VR6: 10k; 3266W
VR2: 50; 3266W
VR3: 500; 3266W
VR4, VR5: 3266W/10k; 3266W
X1: USB-A-H
ZD1: SM6T33CAY; SMB

Connections:
+1.2V_REF: C2.2, IC1.G (V+), IC2.3 (+IN), IC8.2 (REF), IC12.2 (REF), R1.2, VR1.1
+3V3: C21.1, C46.2, C53.1, C54.1, C55.1, C56.1, C71.2, D4.S (C), D6.S (C), D9.G (1), IC6.5 (OUT), IC11.3 (VCC), IC13.17 (VDD_2), IC13.48 (VDD_1), JP20.1, JP21.1, L8.1, R54.2, R61.2, R62.2
+5V: C10.1, C13.2, C16.2, C29.1, C31.1, C33.1, C43.-, C47.2, C49.2, D1.S (C), F2.P$1 (1), IC3.8 (V+), IC4.16 (VCC), IC6.1 (IN), IC6.3 (EN), IC10.4 (PVDD), IC10.5 (!MUTE), IC10.12 (!SHDN), IC10.13 (PVDD), JP2.2, JP3.1, JP3.3, JP5.22, JP5.24, L3.1, L5.1, Q1.1, Q5.1, Q7.1, Q10.1, Q14.S (SOURCE), Q30.1, Q31.1, R2.2, R3.2, R7.2, R13.2, R36.2
+5V/1: C5.1, C36.+, IC2.5 (V+), IC9.3 (Q), Q10.3, R1.1, R9.2, R60.1
+10V: C28.1, C52.1, C63.2, C64.2, C72.2, D7.S (C), D8.S (C), IC8.7 (V+), IC12.7 (V+), IC14.5 (V+), IC15.5 (V+), IC17.3 (OUT)
+12V: C15.1, C19.1, IC5.1 (VDD), IC5.3 (+IN)
+UB: L4.1, R29.2
A0: JP5.16
A1: JP5.18
A2: JP5.20
A3: JP5.15
A4: JP5.17
A5: JP5.19
AGND: C2.1, C5.2, C25.2, C27.2, C28.2, C37.2, C38.2, C39.2, C45.2, C48.2, C51.2, C52.2, C59.2, C60.1, C61.1, C62.1, C67.2, C68.1, C69.1, C70.1, D4.G (A), D6.G (A), D7.G (A), D8.G (A), IC1.S (V-), IC2.2 (V-), IC8.3 (V-), IC10.9 (NC), IC10.11 (GND), IC12.3 (V-), IC13.8 (VSSA/VREF-), IC13.23 (VREFSD-), IC14.2 (V-), IC15.2 (V-), IC16.S (V-), JP6.2, JP14.2, JP17.2, JP22.2, JP23.2, L7.2, R25.1, R39.1, R41.1, R44.1, R47.1, R49.1, R50.1, R51.1, VR1.3, VR6.3
BOOT1: IC13.44 (BOOT0), JP21.2, R55.2
CANH: C40.1, D5.G (PIN1), JP16.1, L6.4, R42.1
CANL: C44.2, D5.S (PIN2), JP16.2, L6.3, SW1.3
CAN_RX: IC11.4 (RXD), IC13.45 (PB8)
CAN_TX: IC11.1 (TXD), IC13.46 (PB9)
COMP1_P: C39.1, D4.D (AC), IC13.11 (PA1), R40.2, R41.2
COMP2_P: C45.1, D6.D (AC), IC13.13 (PA3), R46.2, R47.2
D0_RX: JP5.2
D1_TX: JP5.4
D2_SDA: JP5.6
D3_SCL: JP5.8
D4: JP5.10
D5: JP5.12
D6: JP5.14
D7: JP5.1
D8: JP5.3
D9: JP5.5
D10: JP5.7
D11: JP5.9
D12: JP5.11
D13: JP5.13
D+: R32.2, R33.1, X1.D+
D-: R31.2, X1.D-
DAC1_OUT1: C60.2, IC13.14 (PA4), IC14.3 (+IN)
DAC2_OUT1: C61.2, IC13.16 (PA6), IC15.3 (+IN)
DC-IN: D2.A, F1.P$1 (1), ZD1.A
DC_IN_ADC: C9.1, D1.D (AC), IC13.28 (PD8), R17.2, R18.2
GND: BAT1.-, C3.2, C6.2, C7.1, C9.2, C12.2, C13.1, C14.2, C15.2, C16.1, C18.2, C19.2, C20.1, C21.2, C23.2, C24.1, C29.2, C31.2, C33.2, C35.2, C36.-, C40.2, C41.2, C42.2, C43.+, C44.1, C46.1, C47.1, C49.1, C53.2, C54.2, C55.2, C56.2, C57.1, C58.1, C63.1, C64.1, C65.1, C66.1, C71.1, C72.1, C73.2, D1.G (A), D3.A, D5.D (PIN3), IC3.1 (G), IC3.4 (V-), IC4.15 (GND), IC5.2 (GND), IC6.2 (GND), IC7.3 (GND), IC9.4 (GND), IC10.2 (PGND), IC10.15 (PGND), IC11.2 (GND), IC11.8 (RS), IC13.47 (VSS_1), IC17.2 (GND), IC17.4 (GND), J1.1, JP1.2, JP2.6, JP3.2, JP3.4, JP4.9, JP5.21, JP5.23, JP8.2, JP20.3, L1.2, L7.1, Q4.EMITTER (GND), Q5.7 (O), Q6.EMITTER (GND), Q7.3, Q9.EMITTER (GND), Q11.EMITTER (GND), Q12.EMITTER (GND), Q13.EMITTER (GND), R8.1, R18.1, R21.1, R22.1, R23.1, R26.2, R30.1, R37.1, R55.1, X1.GND, ZD1.C (K)
KELVIN_M: IC13.19 (PB1), JP6.1
KELVIN_P: IC13.18 (PB0), JP7.2
L1: IC13.2 (PC13), Q4.BASE (IN)
L2: IC13.21 (PE8), Q6.BASE (IN)
L3: IC13.22 (PE9), Q9.BASE (IN)
LC_PULSE: IC3.7 (OUT), IC13.35 (PF6), R10.2, R11.2, R13.1
LEFT: C32.2, J2.2
MISO_D14: JP2.1
MOSI_D16: JP2.4
unnamed: C50.2, C51.1, IC12.1 (-IN), R45.2
unnamed: IC16.D (TERMI/NC), R59.1
unnamed: IC7.6 (FB), R36.1, R37.2
unnamed: C22.2, IC7.2 (BST)
unnamed: C42.1, IC11.6 (CANL), L6.2
unnamed: C41.1, IC11.7 (CANH), L6.1
unnamed: R16.1, VR3.3
unnamed: C22.1, R28.1
unnamed: D3.C, IC7.1 (LX), L3.2, R28.2
unnamed: C17.1, IC7.5 (COMP)
unnamed: C17.2, R23.2
unnamed: R42.2, SW1.1
unnamed: C48.1, C50.1, IC12.8 (+IN), R43.2
unnamed: C11.1, IC4.5 (C2-)
unnamed: C11.2, IC4.4 (C2+)
unnamed: C10.2, IC4.2 (V+)
unnamed: IC14.4 (-IN), R52.1, VR4.1
unnamed: D7.D (AC), IC14.1 (OUT), R52.2, R57.1
unnamed: IC7.8 (EN), R20.1, R21.2
unnamed: IC5.5 (OUT), R19.1
unnamed: IC7.4 (FSW), R26.1
unnamed: R50.2, VR4.2
unnamed: IC15.4 (-IN), R53.1, VR5.1
unnamed: C18.1, IC7.7 (SS)
unnamed: D9.D (3), IC13.1 (VBAT), R56.1
unnamed: C7.2, IC4.6 (V-)
unnamed: C8.2, IC4.1 (C+)
unnamed: JP8.1, R19.2
unnamed: C8.1, IC4.3 (C1-)
unnamed: IC2.1 (OUT), Q8.2 (B), R9.1
unnamed: Q12.COLLECTOR (OUT), Q30.8 (2)
unnamed: D8.D (AC), IC15.1 (OUT), R53.2, R58.1
unnamed: R59.2, VR6.2
unnamed: IC13.7 (NRST), R54.1
unnamed: C66.2, IC13.6 (PF1/OSC=>), Q16.3 (2)
unnamed: JP15.2, R44.2, R45.1
unnamed: IC3.5 (BA), IC3.6 (BS)
unnamed: C62.2, C69.2, C70.2, IC13.9 (VDDA/VREF+), IC13.24 (VDDSD), L8.2
unnamed: C6.1, IC3.3 (-IN), R11.1
unnamed: R51.2, VR5.2
unnamed: C26.2, C27.1, IC8.1 (-IN), R27.2
unnamed: C25.1, C26.1, IC8.8 (+IN), R24.2
unnamed: IC10.7 (INL), R38.2
unnamed: IC10.1 (+OUT_L), JP18.1
unnamed: JP12.2, R25.2, R27.1
unnamed: JP12.1, R24.1
unnamed: IC8.6 (OUT), R35.1
unnamed: C4.1, IC3.2 (+IN), R7.1, R8.2, R10.1
unnamed: JP7.1, Q8.3 (C)
unnamed: JP14.1, R40.1
unnamed: JP17.1, R46.1
unnamed: IC10.3 (-OUT_L), JP18.2
unnamed: IC10.14 (-OUT_R), JP19.1
unnamed: IC10.16 (+OUT_R), JP19.2
unnamed: IC10.10 (INR), R34.2
unnamed: C34.1, IC10.8 (VREF)
unnamed: C34.2, J2.1
unnamed: C32.1, R38.1
unnamed: C35.1, F2.P$2 (2), L4.2, X1.VBUS
unnamed: Q14.D (DRAIN), R33.2
unnamed: IC1.D (TERMI/NC), R4.1
unnamed: C20.2, IC6.4 (BP)
unnamed: R4.2, VR1.2
unnamed: R15.1, VR2.3
unnamed: C30.1, R34.1
unnamed: Q10.8 (2), Q11.COLLECTOR (OUT)
unnamed: Q10.4 (S), R15.2
unnamed: C67.1, C68.2, IC13.25 (VREFSD+), IC16.G (V+), R60.2, VR6.1
unnamed: C37.1, IC10.6 (VDD), L5.2
unnamed: IC2.4 (-IN), Q8.1 (E), VR2.2, VR3.2
unnamed: C12.1, J1.2
unnamed: Q10.2 (O), R16.2
unnamed: Q5.4 (S), Q5.5 (S)
unnamed: C1.1, C3.1, C4.2, L2.2, Q5.2 (O)
unnamed: Q7.8 (2), Q9.COLLECTOR (OUT)
unnamed: Q5.8 (2), Q6.COLLECTOR (OUT)
unnamed: Q1.2 (O), Q1.6, Q5.3
unnamed: C1.2, Q7.4 (S)
unnamed: L2.1, Q5.6
unnamed: Q1.8 (2), Q4.COLLECTOR (OUT)
unnamed: JP15.1, R43.1
unnamed: L1.1, Q1.5 (S)
unnamed: JP1.1, Q1.3
unnamed: IC12.6 (OUT), R48.1
unnamed: Q13.COLLECTOR (OUT), Q31.8 (2)
unnamed: JP10.1, Q30.3
unnamed: C65.2, IC13.5 (PF0/OSC<=), Q16.1
unnamed: JP10.2, Q30.2 (O)
unnamed: JP13.1, Q31.3
unnamed: JP13.2, Q31.2 (O)
unnamed: BAT1.+, D9.S (2), R56.2
unnamed: C57.2, IC13.3 (PC14), Q15.1
unnamed: C58.2, IC13.4 (PC15), Q15.4 (2)
PWM1: IC5.4 (-IN), IC13.41 (PB5), R22.2
PWM2: IC13.42 (PB6)
RANGE_SET: IC13.43 (PB7), Q11.BASE (IN)
RELAY1: IC13.36 (PF7), Q12.BASE (IN)
RELAY2: IC13.29 (PA8), Q13.BASE (IN)
RESET: JP2.5
RIGHT: C30.2, J2.3
RXD_LA: IC4.8 (RIN2), IC4.9 (ROUT2), JP9.2, Q2.D, R2.1
RXD_STM: IC4.13 (RIN1), JP11.2
RXI2: IC4.12 (ROUT1), IC13.40 (PB4)
SCK_D15: JP2.3
SCL: IC13.30 (PA9)
SDA: IC13.31 (PA10)
SDADC2_6P: IC13.20 (PB2)
SWCLK: IC13.37 (PA14), JP20.4, R62.1
SWDIO: IC13.34 (PA13), JP20.2, R61.1
TC1_ADC: C38.1, IC13.26 (PB14), R35.2, R39.2
TC2_ADC: C59.1, IC13.27 (PB15), R48.2, R49.2
TXD_LA: IC4.7 (DOUT2), IC4.10 (DIN2), JP9.1, Q3.D, R3.1
TXD_STM: IC4.14 (DOUT1), JP11.1
TXO2: IC4.11 (DIN1), IC13.39 (PB3)
UART_RXI: JP4.5, Q2.S, R5.1
UART_TXO: JP4.7, Q3.S, R6.1
USB_DM: IC13.32 (PA11), R31.1
USB_DP: IC13.33 (PA12), R32.1
USB_EN: IC13.38 (PA15), Q14.G (GATE), R29.1, R30.2
V-OUT: JP22.1, JP23.1, R57.2, R58.2
VDD: JP4.10, Q2.G, Q3.G, R5.2, R6.2
VEE: F1.P$2 (2), J1.3, R17.1
VPP: C14.1, C23.1, C24.2, C73.1, D2.C, IC7.EX_PAD (VIN), IC9.1 (I), IC9.2 (INH), IC17.1 (IN), R20.2
XX: IC13.10 (PA0)
XXX: IC13.12 (PA2)

Notes on the sheet:
+5 Voltage Step Down Regulator
3W STEREO AUDIO AMP
Lattepanda Pin Header
USB
CAN BUS Driver
4-WIRE KELVIN
K-Type Range = -180°C to 1200°C
1.24V REF = -248°C to 752°C
0.9V REF = -180°C to 820°C
0V REF = 0°C to 1000°C
LC METER
DAC
THERMO COUPLE K-TYPE
CH1
CH2
RS232C
REGULATOR

Board: 2 copper layers, 222 parts (1 on the bottom side), 146 nets, no tracks yet.

Notices in the files:
README.md:
License: MIT
