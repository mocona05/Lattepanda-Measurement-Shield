# Keil uVision project F373.uvprojx, settings and files
target F373 (ARM-ADS)
  device: STM32F373CC STMicroelectronics
  pack: Keil.STM32F3xx_DFP.1.3.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(72000000) FPU2 CPUTYPE("Cortex-M4")
  output: F373
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F373xC
  c misc: --C99
  c include: ../Inc;         ../Drivers/STM32F3xx_HAL_Driver/Inc;         ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;         ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;         ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;         ../Middlewares/Third_Party/FreeRTOS/Source/include;         ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;         ../Drivers/CMSIS/Include;         ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;         ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;         ..\User;         ..\mavlink;         ..\..\F373
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_pcd.c stm32f3xx_hal_dac.c stm32f3xx_hal.c stm32f3xx_hal_rtc.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_tim.c stm32f3xx_hal_can.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_flash.c stm32f3xx_hal_gpio.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_adc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Application/MDK-ARM
    ./: startup_stm32f373xc.s
  group Application/User
    ../Src/: main.c freertos.c stm32f3xx_hal_msp.c stm32f3xx_it.c usbd_desc.c usb_device.c usbd_conf.c usbd_cdc_if.c stm32f3xx_hal_timebase_TIM.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: queue.c tasks.c croutine.c list.c event_groups.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_core.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group User
    ../User/: board.h adc.c adc.h lc_meter.c lc_meter.h drv_system.h drv_system.c config.c config.h uart_dma.c uart_dma.h serial.c serial.h vcp.c vcp.h can.c can.h can_queue.h can_queue.c function.c function.h rtc.c rtc.h dac.h dac.c cli.c cli.h Digital_control.h Digital_control.c
  group mavlink
    ../mavlink/: mavlink_helpers.h mavlink_conversions.h
    ../mavlink/Lattepanda_shiled/: mavlink_msg_system_config_setting_data.h mavlink_msg_system_control_set.h Lattepanda_shiled.h mavlink.h mavlink_msg_adc_calibration_data.h mavlink_msg_can_bus_config_setting_data.h mavlink_msg_dac_calibration_data.h mavlink_msg_dac_setting_data.h mavlink_msg_digital_out_setting_data.h mavlink_msg_kelvin_calibration_data.h mavlink_msg_measuring_data.h mavlink_msg_real_time_clock_set.h mavlink_msg_receive_can_data.h mavlink_msg_tc_calibration_data.h mavlink_msg_transmit_can_data.h testsuite.h version.h mavlink_msg_measuring_setting.h
software components: CMSIS:CORE 4.1.0
